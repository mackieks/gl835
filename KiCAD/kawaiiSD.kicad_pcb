File: KiCAD/kawaiiSD.kicad_pcb (KiCad board)
At the start: 2 copper layers, 14.8 x 27.5 mm, 11 parts, among them J1 503398-1892

Commit message: initial commit
Parts:
- U1: value ~ -> GL835
